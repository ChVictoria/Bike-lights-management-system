# Keil uVision project Project.uvprojx, settings and files
target STM32L476RG_SENSORTILE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IROM(0x08004000-0x803FFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM(0x0-0xFFFFFFFFFFFFFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM3(0x0-0xFFFFFFFFFFFFFFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IRAM(0x0-0xFFFFFFFFFFFFFFFF) IRAM2(0x0-0xFFFFFFFFFFFFFFFF) IRAM3(0x0-0xFFFFFFFFFFFFFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L476RG-SensorTile_ALLMEMS2
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,STM32_SENSORTILE,ALLMEMS2,PRIORITY_RTOS
  c include: ../Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Middlewares/ST/BlueNRG-MS/includes;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components/lsm6dsm;../../../../../Drivers/BSP/Components/hts221;../../../../../Drivers/BSP/Components/lps22hb;../../../../../Drivers/BSP/Components/lsm303agr;../../../../../Drivers/BSP/SensorTile;../../../../../Middlewares/ST/STM32_MotionFX_Library/Inc;../../../../../Middlewares/ST/STM32_MotionAR_Library/Inc;../../../../../Middlewares/ST/STM32_MotionCP_Library/Inc;../../../../../Middlewares/ST/STM32_MotionGR_Library/Inc;../../../../../Middlewares/ST/STM32_BlueVoiceADPCM_Library/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Drivers/BSP/Components/stc3115;../../../../../Middlewares/ST/STM32_MetaDataManager;../../../../../Middlewares/ST/BlueNRG-MS/utils;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Drivers/BSP/Components/pcm1774;../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x3c000
  memory RVCT5: ROM 0x780c177b size 0xc004600
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
    ../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c lsm303agr_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsm/: lsm6dsm.c lsm6dsm_reg.c
    ../../../../../Drivers/BSP/Components/pcm1774/: PCM1774.c PCM1774_reg.c
    ../../../../../Drivers/BSP/Components/stc3115/: STC3115_Driver.c
  group Drivers/BSP/SensorTile
    ../../../../../Drivers/BSP/SensorTile/: SensorTile.c SensorTile_audio.c SensorTile_bus.c SensorTile_env_sensors.c SensorTile_env_sensors_ex.c SensorTile_gg.c SensorTile_motion_sensors.c SensorTile_motion_sensors_ex.c SensorTile_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx-Nucleo
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/MetaDataManager
    ../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/STM32_BlueNRG/HCI/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/STM32_BlueNRG/hci_tl_patterns/Basic
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/STM32_BlueVoiceADPCM
    ../../../../../Middlewares/ST/STM32_BlueVoiceADPCM_Library/Lib/: bluevoiceADPCM_200_CM4F_Keil_ot.lib
  group Middlewares/STM32_MotionAR
    ../../../../../Middlewares/ST/STM32_MotionAR_Library/Lib/: MotionAR_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionCP
    ../../../../../Middlewares/ST/STM32_MotionCP_Library/Lib/: MotionCP_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionFX
    ../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionGR
    ../../../../../Middlewares/ST/STM32_MotionGR_Library/Lib/: MotionGR_CM4F_wc16_ot.a
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group STM32L476RG-SensorTile_ALLMEMS2/MDK-ARM
    ./: startup_stm32l476xx.s
  group STM32L476RG-SensorTile_ALLMEMS2/User
    ../Src/: AudioBV_Manager.c datalog_application.c DataLog_Manager.c hci_tl_interface.c HWAdvanceFeatures.c main.c MotionAR_Manager.c MotionCP_Manager.c MotionFX_Manager.c MotionGR_Manager.c OTA.c PowerControl.c sd_diskio_SensorTile.c sensor_service.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
software components: CMSIS:CORE 4.3.0
